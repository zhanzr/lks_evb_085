# Keil uVision project lks_evb_085_v2.uvprojx, settings and files
target lks_evb_085_v2 (6160000::V6.16::ARMCLANG)
  device: LKS32MC085C8Q9 Linko
  pack: Linko.LKS08x.1.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lks_evb_085_v2
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\lks32mc08x_periph_driver\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1ffc
  group App
    ./: app.c hardware_config.h hardware_init.h hardware_init.c interrupt.c dsp_periph.c dsp_periph.h
  group perh_driver
    ../lks32mc08x_periph_driver/Source/: lks32mc08x_DMA.c lks32mc08x_dsp.c lks32mc08x_exti.c lks32mc08x_gpio.c lks32mc08x_iwdg.c lks32mc08x_MCPWM.c lks32mc08x_spi.c lks32mc08x_sys.c lks32mc08x_tim.c lks32mc08x_uart.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
